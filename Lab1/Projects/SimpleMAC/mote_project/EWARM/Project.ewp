# IAR project Project.ewp, settings and files
configuration MB851_TALK (ARM, debug)
  General.OGChipSelectEditMenu: STM32W108CC ST STM32W108CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB851_REVD; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB851; ..\..; ..\..\arm_mote
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: talk.s37
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32w108xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB950_TALK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB950; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB950
configuration MB951_TALK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB951; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB951
configuration MB954_TALK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB954_REVC; STM32W108CC; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\stm32w108; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\generic\compiler; ..\..\..\..\Utilities\STM32W108xx_HAL_Driver\micro\cortexm3\bootloader; ..\..\..\..\Utilities\Shared; ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32W108xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32W108xx\Include; ..\..\..\..\Libraries\SimpleMAC\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\MB954
configuration MB_SnT_X2_Mote (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_MB_SNT_X2; STM32W108CB; PLATFORM_HEADER="Utilities\STM32W108xx_HAL_Driver/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  group CMSIS
    ../../../../Libraries/CMSIS/Device/ST/STM32W108xx/Source/Templates/: system_stm32w108xx.c
  group EWARM
    ./: startup_stm32w108xx.s
  group Mote_Apps
    ../: mote.c
  group Mote_Apps/APP_TEMP_1WIRE
    ../../arm_mote/APP_TEMP_1WIRE/: app_temp_1wire_main.c
  group Mote_Apps/PRJ_NET_ONLY
    ../../arm_mote/PRJ_NET_ONLY/: config.c network_only_include_c.c
  group Mote_Libs
    ../../arm_mote/: Application.c Application.h common.h common_constants.h feat_enable.h hw_specific.h main.c network_hardware.h network_hardware_ADFS.h network_hardware_LGS.h packet.c packet.h sys_func.c sys_func.h
  group Mote_Libs/defs
    ../../arm_mote/defs/: esnl_pub.h
  group Mote_Libs/doc
    ../../arm_mote/doc/: New_config_format.odt templet_file.c
  group Mote_Libs/FEAT_adpcm
    ../../arm_mote/FEAT_adpcm/: decode.c encode.c g711.c g711.h g721.c g723_16.c g723_24.c g723_40.c g72x.c g72x.h
  group Mote_Libs/FEAT_BaseStation
    ../../arm_mote/FEAT_BaseStation/: bs_base.c
  group Mote_Libs/FEAT_CogNet
    ../../arm_mote/FEAT_CogNet/: microstrain.c microstrain.h rssi_sensor.c rssi_sensor.h rtls_beacon.c rtls_beacon.h rtls_calculate.c rtls_calculate.h
  group Mote_Libs/FEAT_HIO
    ../../arm_mote/FEAT_HIO/: hio_xbee.c hio_xbee_prv.h hio_xbee_pub.h
  group Mote_Libs/FEAT_LCD
    ../../arm_mote/FEAT_LCD/: lcd_char2x8.c lcd_char2x8.h
  group Mote_Libs/FEAT_Networking
    ../../arm_mote/FEAT_Networking/: ChannelSwitching.c ChannelSwitching.h CongestionControl.c CongestionControl.h Phy_layer.c Phy_layer.h tsp_common.c tsp_common_prv.h tsp_common_pub.h
  group Mote_Libs/FEAT_Queuing
    ../../arm_mote/FEAT_Queuing/: Q_Droptail.c Q_Droptail.h Q_SFQ.c Q_SFQ.h Queuing.c Queuing.h
  group Mote_Libs/FEAT_Routing
    ../../arm_mote/FEAT_Routing/: mpr_selector_table.c mpr_selector_table.h packet_AODV.h routing.c routing.h routing_AODV.c routing_AODV.h routing_MMCR.c routing_MMCR.h routing_MMCR_MPR_select.c routing_MMCR_MPR_select.h routing_OEDSR.c routing_OEDSR.h
  group Mote_Libs/FEAT_Scheduler
    ../../arm_mote/FEAT_Scheduler/: sch_basic.c sch_basic_prv.h sch_basic_pub.h timer.cpp timer.h
  group Mote_Libs/FEAT_SigProc
    ../../arm_mote/FEAT_SigProc/: sig_basic.c sig_basic_prv.h sig_basic_pub.h src_8bit_adc.c src_8bit_adc_prv.h src_8bit_adc_pub.h src_dummy.c src_dummy_prv.h src_dummy_pub.h ssn_8bit.c ssn_8bit_prv.h ssn_8bit_pub.h ssn_basic.c ssn_basic_prv.h ssn_basic_pub.h
  group Mote_Libs/FEAT_STM32W
    ../../arm_mote/FEAT_STM32W/: STM32W_Radio.c STM32W_Radio.h
  group Mote_Libs/HW_LIB
    ../../arm_mote/HW_LIB/: arm_adc.c arm_adc.h OneWire.c OneWire.h RTC.c RTC.h
  group Simplemac_Library
    ../../../../Libraries/SimpleMAC/Binary/: simplemac-library.a
  group StdPeriph_Driver
    ../../../../Libraries/STM32W108xx_StdPeriph_Driver/src/: stm32w108xx_adc.c stm32w108xx_clk.c stm32w108xx_exti.c stm32w108xx_flash.c stm32w108xx_gpio.c stm32w108xx_misc.c stm32w108xx_pwr.c stm32w108xx_rst.c stm32w108xx_sc.c stm32w108xx_slptim.c stm32w108xx_tim.c stm32w108xx_wdg.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/MB851/: mb851.c
    ../../../../Utilities/STM32_EVAL/MB950/: mb950.c
    ../../../../Utilities/STM32_EVAL/MB951/: mb951.c
    ../../../../Utilities/STM32_EVAL/MB954/: mb954.c
    ../../../../Utilities/STM32_EVAL/MB_SnT_X2/: mb_snt_x2.c mb_snt_x2.h
  group STM32W108xx_HAL_Driver
    ../../../../Utilities/STM32W108xx_HAL_Driver/micro/cortexm3/: board.c context-switch.s79 hal_adc.c hal_clocks.c hal_flash.c hal_uart.c mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c system-timer.c
    ../../../../Utilities/STM32W108xx_HAL_Driver/micro/cortexm3/stm32w108/: low_level_init.c
  group Talk_Application
    ../: solar-system.c stm32w108xx_conf.h stm32W108xx_it.c stm32w108xx_it.h transmit.c transmit.h
